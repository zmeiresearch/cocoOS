<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cocoOS_stm32f0_blink.ewp</path>
  </project>
  <batchBuild/>
</workspace>


