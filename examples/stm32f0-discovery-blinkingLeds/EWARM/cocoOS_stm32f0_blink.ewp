# IAR project cocoOS_stm32f0_blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\..\..\cocoos\base\inc; ..\..\..\ports\stm32f0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group cocoOS_base/inc
    ../../../cocoos/base/inc/: cocoos.h os_applAPI.h os_assert.h os_defines.h os_event.h os_msgqueue.h os_sem.h os_task.h os_typedef.h
  group cocoOS_base/src
    ../../../cocoos/base/src/: os_event.c os_kernel.c os_msgqueue.c os_sem.c os_task.c
  group cocoOS_port/inc
    ../../../ports/stm32f0/inc/: os_port.h stm32f030.h stm32f0x_gpio.h stm32f0x_nvic.h stm32f0x_rcc.h
  group cocoOS_port/src
    ../../../ports/stm32f0/src/: os_assert.c os_cbk.c
